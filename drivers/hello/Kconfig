## drivers/hello/Kconfig
```kconfig
config HELLO
	tristate "Chang's First Linux Driver"
	default n
	help
	This is the first android driver.
```
